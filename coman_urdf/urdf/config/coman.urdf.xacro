Commit message: xtion is working again now

File: coman_urdf/urdf/config/coman.urdf.xacro (robot description, xacro)
@@ -123,4 +123,4 @@
 #
 -->
-<xacro:property name="GAZEBO_COMAN_USES_XTION" value="false" />
+<xacro:property name="GAZEBO_COMAN_USES_XTION" value="true" />
 </robot>
